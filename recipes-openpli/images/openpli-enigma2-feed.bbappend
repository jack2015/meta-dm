OPTIONAL_PACKAGES_remove_dm800 += "\
	lirc \
	iptraf \
	"

OPTIONAL_PACKAGES_remove_dm900 += "\
	rtl8192cu \
	"

OPTIONAL_PACKAGES_remove_dm920 += "\
	rtl8192cu \
	"
